# Repository Yatekii/project-powerline

## KiCad design hardware/supervisor/supervisor.kicad_pcb

Schematic: supervisor.sch

Parts:
C1, C2: CP_Small; C_Radial_D7.5_L11.2_P2.5
C3, C4, C5: 0.1 uF; C_0603_HandSoldering
C6: 22pF; C_0603_HandSoldering
C7: 100nF; C_0603_HandSoldering
D1: Led_Small; Pin_Header_Straight_1x02
D2, D3, D4: Led_Small; LED_0603
D5: ZENERsmall; SMB-SMC_Universal_Handsoldering
IC1: ULN2003A; SOIC-16_3.9x9.9mm_Pitch1.27mm
IC2: LM2596-3.3; TO-263-5Lead
IC3: MAX11612; TSSOP-8_4.4x3mm_Pitch0.65mm
IC4, IC5, IC6: ACS723LLCTR-10AU-T; SOIC-8-N
IC7, IC8: NLSX4373; SOIC-8-N
IC9: SIM900; QFP 68
K1, K2: RELAY_SERIE_36
L1: INDUCTOR_Small; HC9-large
P1: 230V_IN; CONNECTOR-input
P2: RASPI-CONNECT; Pin_Header_Straight_2x20
P3: POWER; Pin_Header_Straight_1x02
P4, P6, P7, P8, P12: CONN_01X03; CONNECTOR-relay
P5, P13, P14, P15: 230V_OUT; Pin_Header_Straight_1x02
R1, R2, R3, R4: R_Small; R_0603_HandSoldering
R5, R6: 22; R_0603_HandSoldering
R7: 22; R_1206_HandSoldering
SW1, SW2: SW_PUSH; Pin_Header_Straight_1x02
U1, U2, U3: SC16IS740IPW; TSSOP-16_4.4x5mm_Pitch0.65mm
U4: RF_CONN; SMA_SMD
U5: SIM_HOLDER

Connections:
+3V3: C2.1, IC2.4, IC7.8, IC8.1, IC8.5, IC9.55, IC9.56, IC9.57, L1.2, U1.1, U1.3, U1.8, U1.14, U2.1, U2.2, U2.8, U2.14, U3.1, U3.8, U3.14; also elsewhere on the board
/FSK Module 1/incoming1: U1.13; also elsewhere on the board
/FSK Module 1/outgoing1: U1.12; also elsewhere on the board
/FSK Module 2/incoming2: U2.13; also elsewhere on the board
/FSK Module 2/outgoing2: U2.12; also elsewhere on the board
/FSK Module 3/incoming3: U3.13; also elsewhere on the board
/FSK Module 3/outgoing3: U3.12; also elsewhere on the board
BT0: P2.40, SW1.1
BT1: P2.38, SW2.1
ENSK0: P2.22; also elsewhere on the board
ENSK1: P2.26; also elsewhere on the board
ENSK2: P2.32; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D5.2, IC1.8, IC2.3, IC2.5, IC3.7, IC4.5, IC5.5, IC6.5, IC7.4, IC8.4, IC9.17, IC9.18, IC9.29, IC9.39, IC9.45, IC9.46, IC9.53, IC9.54, IC9.58, IC9.59, IC9.61, IC9.62, IC9.63, IC9.64, IC9.65, P2.6, P2.9, P2.14, P2.20, P2.25, P2.30, P2.34, P2.39, P3.1, SW1.2, SW2.2, U1.2, U1.9, U2.3, U2.9, U3.2, U3.3, U3.9, U4.2, U5.C5; also elsewhere on the board
GSM_LED0: IC1.3, IC9.66
GSM_LED1: IC1.4, IC9.52
GSM_PKEY: IC1.10, IC9.1
GSM_PWR: IC1.7, P2.29
IRQ0: P2.12, U3.7
IRQ1: P2.16, U2.7
IRQ2: P2.18, U1.7
LED0: IC1.1, P2.35
LED1: IC1.2, P2.37
MUCLK: P2.7, U1.15, U2.15, U3.15
unnamed: C6.1, R5.1, U5.C7
unnamed: C7.1, IC9.30, U5.C1
unnamed: D1.1 (K), IC1.16
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), IC1.15
unnamed: D2.2 (A), R2.2
unnamed: D3.1 (K), IC1.14
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), IC1.13
unnamed: D4.2 (A), R4.2
unnamed: D5.1, IC2.2, L1.1
unnamed: IC1.11, K2.A2
unnamed: IC1.12, K1.A2
unnamed: IC3.5, IC7.3
unnamed: IC3.6, IC7.2
unnamed: IC8.6, IC9.10
unnamed: IC8.7, IC9.9
unnamed: IC8.8, IC9.15
unnamed: IC9.31, R5.2
unnamed: IC9.32, R6.1
unnamed: IC9.33, R7.2
unnamed: IC9.60, U4.1
unnamed: K1.11, P4.2
unnamed: K1.12, P4.3
unnamed: K1.14, P4.1
unnamed: K2.11, P12.2
unnamed: K2.12, P12.3
unnamed: K2.14, P12.1
unnamed: P1.1, P5.2
unnamed: P1.2, P5.1
unnamed: P6.3, P13.1
unnamed: P7.3, P14.1
unnamed: P8.3, P15.1
unnamed: R6.2, U5.C3
unnamed: R7.1, U5.C2
PGND0: P6.2; also elsewhere on the board
PGND1: P7.2; also elsewhere on the board
PGND2: P8.2; also elsewhere on the board
RLY0: IC1.5, P2.31
RLY1: IC1.6, P2.33
RXD: IC8.2, P2.10
SCL: IC7.6, P2.28, U1.5, U2.5, U3.5
SDA: IC7.7, P2.27, U1.6, U2.6, U3.6
TXD: IC8.3, P2.8
isense0: IC3.1, IC4.7
isense1: IC3.2, IC5.7
isense2: IC3.3, IC6.7
string_in0: IC4.1, IC4.2, P13.2; also elsewhere on the board
string_in1: IC5.1, IC5.2, P14.2; also elsewhere on the board
string_in2: IC6.1, IC6.2, P15.2; also elsewhere on the board
string_out0: IC4.3, IC4.4, P6.1
string_out1: IC5.3, IC5.4, P7.1
string_out2: IC6.3, IC6.4, P8.1

Parts:
C19: C_Small; Pin_Header_Straight_1x02
C20, C23, C24: C_Small; C_0603
C21: 100n; C_0603
C22: 0.1u; C_0603
D6: D_Schottky_Small; SOD-123
P9: CONN_01X03; Pin_Header_Straight_1x03
R22: 10k; R_0603
R23: x; R_0603
R24, R28, R29: 100k; R_0603
R25, R26, R27, R30: R_Small; R_0603
RV3: POT; EVM-1USX30B14_poti
U9: CD74HC4046; SOIC-16_3.9x9.9mm_Pitch1.27mm
U10: OPA376AIDCK; SC-70-6

Connections:
+3V3: C21.1, R24.1, U9.16 (VCC), U10.5 (V+); also elsewhere on the board
/FSK Module 1/coupling1: C19.2, D6.2 (A), U9.4 (VCOout)
/FSK Module 1/incoming1: C24.1, R30.1; also elsewhere on the board
/FSK Module 1/outgoing1: R22.2; also elsewhere on the board
ENSK2: U9.5 (INH); also elsewhere on the board
GND: C20.2, C21.2, C22.2, C24.2, R23.2, R25.2, R27.1, R29.2, RV3.2, U9.3 (COMPin), U9.8 (GND), U9.14 (SIGin), U10.2 (V-); also elsewhere on the board
unnamed: C19.1, P9.2
unnamed: C20.1, R22.1, R23.1, R24.2, U9.9 (VCOin)
unnamed: C22.1, D6.1 (K), R27.2, U10.1 (+)
unnamed: C23.1, U9.6 (C1a)
unnamed: C23.2, U9.7 (C1b)
unnamed: R25.1, U9.11 (R1)
unnamed: R26.1, U9.12 (R2)
unnamed: R26.2, RV3.3
unnamed: R28.1, R30.2, U10.4
unnamed: R28.2, R29.1, U10.3 (-)
PGND2: P9.1; also elsewhere on the board
string_in2: P9.3; also elsewhere on the board

Notes on the sheet:
Transmitter
Reciever
MCU
Interface

Parts:
C25: C_Small; Pin_Header_Straight_1x02
C26, C29, C30: C_Small; C_0603
C27: 100n; C_0603
C28: 0.1u; C_0603
D7: D_Schottky_Small; SOD-123
P10: CONN_01X03; Pin_Header_Straight_1x03
R31: 10k; R_0603
R32: x; R_0603
R33, R37, R38: 100k; R_0603
R34, R35, R36, R39: R_Small; R_0603
RV4: POT; EVM-1USX30B14_poti
U11: CD74HC4046; SOIC-16_3.9x9.9mm_Pitch1.27mm
U12: OPA376AIDCK; SC-70-6

Connections:
+3V3: C27.1, R33.1, U11.16 (VCC), U12.5 (V+); also elsewhere on the board
/FSK Module 2/coupling2: C25.2, D7.2 (A), U11.4 (VCOout)
/FSK Module 2/incoming2: C30.1, R39.1; also elsewhere on the board
/FSK Module 2/outgoing2: R31.2; also elsewhere on the board
ENSK1: U11.5 (INH); also elsewhere on the board
GND: C26.2, C27.2, C28.2, C30.2, R32.2, R34.2, R36.1, R38.2, RV4.2, U11.3 (COMPin), U11.8 (GND), U11.14 (SIGin), U12.2 (V-); also elsewhere on the board
unnamed: C25.1, P10.2
unnamed: C26.1, R31.1, R32.1, R33.2, U11.9 (VCOin)
unnamed: C28.1, D7.1 (K), R36.2, U12.1 (+)
unnamed: C29.1, U11.6 (C1a)
unnamed: C29.2, U11.7 (C1b)
unnamed: R34.1, U11.11 (R1)
unnamed: R35.1, U11.12 (R2)
unnamed: R35.2, RV4.3
unnamed: R37.1, R39.2, U12.4
unnamed: R37.2, R38.1, U12.3 (-)
PGND1: P10.1; also elsewhere on the board
string_in1: P10.3; also elsewhere on the board

Notes on the sheet:
Transmitter
Reciever
MCU
Interface

Parts:
C42: C_Small; Pin_Header_Straight_1x02
C43, C46, C47: C_Small; C_0603
C44: 100n; C_0603
C45: 0.1u; C_0603
D8: D_Schottky_Small; SOD-123
P11: CONN_01X03; Pin_Header_Straight_1x03
R54: 10k; R_0603
R55: x; R_0603
R56, R60, R61: 100k; R_0603
R57, R58, R59, R62: R_Small; R_0603
RV7: POT; EVM-1USX30B14_poti
U16: CD74HC4046; SOIC-16_3.9x9.9mm_Pitch1.27mm
U17: OPA376AIDCK; SC-70-6

Connections:
+3V3: C44.1, R56.1, U16.16 (VCC), U17.5 (V+); also elsewhere on the board
/FSK Module 3/coupling3: C42.2, D8.2 (A), U16.4 (VCOout)
/FSK Module 3/incoming3: C47.1, R62.1; also elsewhere on the board
/FSK Module 3/outgoing3: R54.2; also elsewhere on the board
ENSK0: U16.5 (INH); also elsewhere on the board
GND: C43.2, C44.2, C45.2, C47.2, R55.2, R57.2, R59.1, R61.2, RV7.2, U16.3 (COMPin), U16.8 (GND), U16.14 (SIGin), U17.2 (V-); also elsewhere on the board
unnamed: C42.1, P11.2
unnamed: C43.1, R54.1, R55.1, R56.2, U16.9 (VCOin)
unnamed: C45.1, D8.1 (K), R59.2, U17.1 (+)
unnamed: C46.1, U16.6 (C1a)
unnamed: C46.2, U16.7 (C1b)
unnamed: R57.1, U16.11 (R1)
unnamed: R58.1, U16.12 (R2)
unnamed: R58.2, RV7.3
unnamed: R60.1, R62.2, U17.4
unnamed: R60.2, R61.1, U17.3 (-)
PGND0: P11.1; also elsewhere on the board
string_in0: P11.3; also elsewhere on the board

Notes on the sheet:
Transmitter
Reciever
MCU
Interface

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
Board: 2 copper layers, 103.1 x 86.6 mm, 110 parts (55 on the bottom side), 110 nets.

## KiCad design hardware/sensor/sensor.kicad_pcb

Parts:
C1: 2.2uF; C_1210
C3, C4, C10, C18: C_Small; C_0603
C5: 0.1u; C_0603
C8: 100nF; C_0603
C11: 10uF; C_1206
C12: C_Small; C_0805
C14, C15: 100n; C_0603
C17: 1u; C_0805
D1, D3: D_Schottky_Small; SOD-123
D2: ZENER; SOD-323
D_BLUE1: BLUE; LED_0603
D_RED1: RED; LED_0603
L1: 22uH; SMD-1210_Pol
P1: CONN_01X05; Molex_PicoBlade_53261-0571
R1, R15, R20: 10k; R_0603
R2, R3, R21, R24: 100k; R_0603
R4: 1M8; R_0805
R5, R7, R8, R10: R_Small; R_0603
R6: x; R_0603
R16: 600k; R_0805
R17: 33k; R_0603
R18, R19: 100; R_0603
RV1: POT; EVM-1USX30B14_poti
R_FB1: 33k; R_0603
R_FB2: 10k; R_0603
SW1: Reset; SW_SPST_PTS645
SW_CSTM1: Cstm; SW_SPST_PTS645
T1: BUK9Y22; SOT-669_LFPAK_ThermalVias-1
T2: DMP10H4D2s; SOT-23
U1: LMR16006; TSOT-6-MK06A
U2: OPA376AIDCK; SC-70-6
U3: CD74HC4046; SOIC-16_3.9x9.9mm_Pitch1.27mm
U5: Atmel_SAM_D09; QFN-24-1EP_4x4mm_Pitch0.5mm
X1: 60V; Pin_Header_Angled_1x02
X2: UART; Molex_PicoBlade_53261-0471

Connections:
/BLUE_ON: D_BLUE1.1 (K), U5.12 (PA15)
/INH-Tx: U3.5 (INH), U5.14 (PA17)
/RED_ON: D_RED1.1 (K), U5.11 (PA14)
/RX1_out: C4.1, R10.1, U5.22 (PA25)
/SHD: R4.2, U1.4 (~SHDN)
/SW_CSTM: C17.1, R20.2, SW_CSTM1.1, U5.13 (PA16)
/TX1_in: R1.2, T1.4 (G), U5.21 (PA24)
/adc_0: C18.1, R16.2, R17.1, U5.1 (PA02)
/coupling: C12.2, D3.2 (A), T1.5 (D), U3.4 (VCOout)
GND: C1.2, C3.2, C4.2, C5.2, C11.2, C14.2, C15.2, C17.2, C18.2, D1.2 (A), P1.1, R2.2, R5.1, R6.2, R7.2, R17.2, R24.2, RV1.2, R_FB2.2, SW1.1, SW_CSTM1.2, T1.1 (S), T1.2 (S), T1.3 (S), U1.2 (GND), U2.2 (V-), U3.3 (COMPin), U3.8 (GND), U3.14 (SIGin), U5.23 (GND), U5.25 (GND), X1.2, X2.4
unnamed: C1.1, D2.1, R4.1, T2.2, U1.5 (VIN)
unnamed: C3.1, R1.1, R6.1, R21.2, U3.9 (VCOin)
unnamed: C5.1, D3.1 (K), R5.2, U2.1 (+)
unnamed: C8.1, U1.1 (CB)
unnamed: C8.2, D1.1 (K), L1.1, U1.6 (SW)
unnamed: C10.1, U3.6 (C1a)
unnamed: C10.2, U3.7 (C1b)
unnamed: D2.2, R24.1, T2.1
unnamed: D_BLUE1.2 (A), R19.2
unnamed: D_RED1.2 (A), R18.2
unnamed: P1.2, U5.20 (PA31/SWDIO)
unnamed: P1.3, U5.19 (PA30/SWCLK)
unnamed: P1.4, R15.2, SW1.2, U5.18 (PA28/~RST)
unnamed: R2.1, R3.2, U2.3 (-)
unnamed: R7.1, U3.11 (R1)
unnamed: R8.1, U3.12 (R2)
unnamed: R8.2, RV1.3
unnamed: R3.1, R10.2, U2.4
unnamed: R_FB1.2, R_FB2.1, U1.3 (FB)
unnamed: U5.3 (PA04), X2.2
unnamed: U5.4 (PA05), X2.3
VCC: C12.1, R16.1, T2.3, X1.1

Notes on the sheet:
Power Supply
Transmitter
Reciever
MCU
Sensor
Interface
Transmitter 2

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
Board: 2 copper layers, 25.7 x 45.5 mm, 49 parts (23 on the bottom side), 33 nets.

## Code that names these connections

File software/sensor/P0werline/atmel_start.c:

/*
 * Code generated from Atmel Start.
 *
 * This file will be overwritten when reconfiguring your Atmel Start project.
 * Please copy examples or other code you want to keep to a separate file
 * to avoid losing it when reconfiguring.
 */

#include "atmel_start.h"
#include <utils.h>
#include <hal_init.h>
#include <hpl_irq.h>
#include <hpl_pm1_v201_base.h>
#include <hpl_gclk1_v210_base.h>
#include <peripheral_gclk_config.h>
#include <hal_usart_async.h>
#include <helpers.h>

#if CONF_DMAC_MAX_USED_DESC > 0
#endif

/*! The buffer size for USART */
#define USART_0_BUFFER_SIZE 16
/*! The buffer size for ADC */
#define ADC_0_BUFFER_SIZE 16

extern struct _irq_descriptor *_irq_table[PERIPH_COUNT_IRQn];
extern void Default_Handler(void);

struct usart_async_descriptor USART_0;
struct adc_async_descriptor ADC_0;

static uint8_t USART_0_buffer[USART_0_BUFFER_SIZE];
static uint8_t ADC_0_buffer[ADC_0_BUFFER_SIZE];

/**
 * \brief USART Clock initialization function
 *
 * Enables register interface and peripheral clock
 */
void USART_0_CLOCK_init()
{
	_pm_enable_bus_clock(PM_BUS_APBC, SERCOM0);
	_gclk_enable_channel(SERCOM0_GCLK_ID_CORE, CONF_GCLK_SERCOM0_CORE_SRC);
	_gclk_enable_channel(SERCOM0_GCLK_ID_SLOW, CONF_GCLK_SERCOM0_SLOW_SRC);
}

/**
 * \brief USART pinmux initialization function
 *
 * Set each required pin to USART functionality
 */
void USART_0_PORT_init()
{
	gpio_set_pin_function(PA04, PINMUX_PA04D_SERCOM0_PAD0);

	gpio_set_pin_function(PA05, PINMUX_PA05D_SERCOM0_PAD1);
}

/**
 * \brief USART initialization function
 *
 * Enables USART peripheral, clocks and initializes USART driver
 */
void USART_0_init(void)
{
	USART_0_CLOCK_init();
	usart_async_init(&USART_0, SERCOM0, USART_0_buffer, USART_0_BUFFER_SIZE);
	USART_0_PORT_init();
}

/**
 * \brief ADC initialization function
 *
 * Enables ADC peripheral, clocks and initializes ADC driver
 */
static void ADC_0_init(void)
{
	_pm_enable_bus_clock(PM_BUS_APBC, ADC);
	_gclk_enable_channel(ADC_GCLK_ID, CONF_GCLK_ADC_SRC);
	adc_async_init(&ADC_0, ADC, ADC_0_buffer, ADC_0_BUFFER_SIZE);
  adc_async_set_resolution(&ADC_0, 12);

	// Disable digital pin circuitry
	gpio_set_pin_direction(PA02, GPIO_DIRECTION_OFF);
	gpio_set_pin_function(PA02, PINMUX_PA02B_ADC_AIN0);
}

void SERCOM0_Handler(void)
{
	if (_irq_table[ SERCOM0_IRQn + 0 ]) {
		_irq_table[ SERCOM0_IRQn + 0 ]->handler(
				_irq_table[ SERCOM0_IRQn + 0 ]->parameter);
	} else {
		Default_Handler();
	}
}
void ADC_Handler(void)
{
	if (_irq_table[ ADC_IRQn + 0 ]) {
		_irq_table[ ADC_IRQn + 0 ]->handler(
				_irq_table[ ADC_IRQn + 0 ]->parameter);
	} else {
		Default_Handler();
	}
}
void DMAC_Handler(void)
{
	if (_irq_table[  +0 ]) {
		_irq_table[  +0 ]->handler(_irq_table[  +0 ]->parameter);
	} else {
		Default_Handler();
	}
}
void SYSCTRL_Handler(void)
{
	if (_irq_table[ SYSCTRL_IRQn + 0 ]) {
		_irq_table[ SYSCTRL_IRQn + 0 ]->handler(
				_irq_table[ SYSCTRL_IRQn + 0 ]->parameter);
	} else {
		Default_Handler();
	}
}
void PM_Handler(void)
{
	if (_irq_table[ PM_IRQn + 0 ]) {
		_irq_table[ PM_IRQn + 0 ]->handler(_irq_table[ PM_IRQn + 0 ]->parameter);
	} else {
		Default_Handler();
	}
}

/**
 * Example of using USART_0 to write "Hello World" using the IO abstraction.
 *
 * Since the driver is asynchronous we need to use statically allocated memory for string
 * because driver initiates transfer and then returns before the transmission is completed.
 *
 * Once transfer has been completed the tx_cb function will be called.
 */

static void tx_cb_USART_0(const struct usart_async_descriptor *const io_descr)
{
	/* Transfer completed */
}

static void rx_cb(const struct usart_async_descriptor *const io_descr)
{
	/* Receive completed */
}

static void err_cb(const struct usart_async_descriptor *const io_descr)
{
	/* Error occurred */
}

static void convert_cb_ADC_0(const struct adc_async_descriptor *const descr)
{

}

void USART_setup(void){
  usart_async_register_callback(&USART_0, USART_ASYNC_TXC_CB, tx_cb_USART_0);
	usart_async_register_callback(&USART_0, USART_ASYNC_RXC_CB, rx_cb);
	usart_async_register_callback(&USART_0, USART_ASYNC_ERROR_CB, err_cb);
}

/**
 * Example of using ADC_0 to generate waveform.
 */
void ADC_0_example(void)
{
	adc_async_register_callback(&ADC_0, ADC_ASYNC_CONVERT_CB, convert_cb_ADC_0);
	adc_async_enable(&ADC_0);
	adc_async_start_conversion(&ADC_0);
}

void system_init(void)
{
	init_mcu();

	// GPIO on PA14

	// Set pin direction to output
	gpio_set_pin_direction(LED_RED, GPIO_DIRECTION_OUT);

	gpio_set_pin_level(LED_RED,
	        // <y> Initial level
	        // <id> pad_initial_level
	        // <false"> Low
	        // <true"> High
			true);

	gpio_set_pin_function(LED_RED, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA15

	// Set pin direction to output
	gpio_set_pin_direction(LED_GREEN, GPIO_DIRECTION_OUT);

	gpio_set_pin_level(LED_GREEN,
	        // <y> Initial level
	        // <id> pad_initial_level
	        // <false"> Low
	        // <true"> High
			true);

	gpio_set_pin_function(LED_GREEN, GPIO_PIN_FUNCTION_OFF);

	USART_0_init();
	ADC_0_init();
}
